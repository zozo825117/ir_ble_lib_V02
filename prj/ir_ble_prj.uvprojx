# Keil uVision project ir_ble_prj.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ir_ble_prj +hex
  AfterMake: fromelf --vhx --32x1 -o .\Objects\ir_ble_prj.bin .\Objects\ir_ble_prj.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\app;..\core;..\drive;..\lib\inc;..\lib\blecomm;.\RTE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Core
    ../core/: system_cx32l003.c startup_cx32l003.s
  group App
    ../app/: main.c
  group Lib
    ../lib/src/: cx32l003_adc.c cx32l003_advtim.c cx32l003_awk.c cx32l003_beeper.c cx32l003_clktrim.c cx32l003_crc.c cx32l003_debug.c cx32l003_exti.c cx32l003_flash.c cx32l003_gpio.c cx32l003_i2c.c cx32l003_it.c cx32l003_iwdt.c cx32l003_lptimer.c cx32l003_lpuart.c cx32l003_lvd.c cx32l003_owire.c cx32l003_pca.c cx32l003_rcc.c cx32l003_rtc.c cx32l003_spi.c cx32l003_syscon.c cx32l003_timer.c cx32l003_uart.c cx32l003_vc.c cx32l003_wwdt.c misc.c
  group Dev
    ../drive/: delay.c system.c basetime.c debug_uart.c spi.c
  group Blecomm
    ../lib/blecomm/: blecomm.c
    ../lib/blecomm/os/: os.c
    ../lib/blecomm/ble/mac/: netstack_mac.c
    ../lib/blecomm/ble/net/: netstack_net.c
    ../lib/blecomm/ble/phy/: netstack_phy.c
software components: CMSIS:CORE 4.3.0
